FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_T30 += "file://u-boot-product.patch"
